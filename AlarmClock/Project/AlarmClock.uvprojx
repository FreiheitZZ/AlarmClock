# Keil uVision project AlarmClock.uvprojx, settings and files
target AlarmClock (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Source\Platform\CPU\CORE;..\Source\Platform\LIB\FWLIB\inc;..\Source\Platform\RTOS\FreeRTOS\include;..\Source\Platform\RTOS\FreeRTOS\portable\RVDS\ARM_CM4F;..\Source\Platform\CPU\stm32f4xx
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../Source/Main/: main.c
    ../Source/Platform/CPU/stm32f4xx/: stm32f4xx_it.c system_stm32f4xx.c
  group Device
    ../Source/Device/BEEP/: beep.c
    ../Source/Device/EXTI/: exti.c
    ../Source/Device/KEY/: key.c
    ../Source/Device/LCD/: lcd.c
    ../Source/Device/LED/: led.c
    ../Source/Device/SRAM/: sram.c
    ../Source/Device/TIMER/: timer.c
  group Common
    ../Source/Common/: delay.c malloc.c sys.c usart.c
  group CORE
    ../Source/Platform/CPU/CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../Source/Platform/LIB/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS_CORE
    ../Source/Platform/RTOS/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../Source/Platform/RTOS/FreeRTOS/portable/MemMang/: heap_4.c
    ../Source/Platform/RTOS/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group README
    ../: readme.txt
